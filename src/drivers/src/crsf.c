#include "crsf.h"
#include "uart.h"
#include "mutex.h"
#include "scheduler.h"
#include <stddef.h>
#include <string.h>

#define CRSF_UART_ID                        UART_1
#define CRSF_BAUD                           420000U
#define CRSF_FRAME_TIMEOUT_MS               50U

#define CRSF_SYNC_BYTE                      0xC8U
#define CRSF_MAX_FRAME_SIZE                 64U
#define CRSF_FRAMETYPE_RC_CHANNELS_PACKED   0x16U
#define CRSF_RC_CHANNELS_PAYLOAD_SIZE       22U
#define CRSF_BITS_PER_CHANNEL               11U

static const uint8_t crsf_crc8_table[256] = {
  0x00, 0xD5, 0x7F, 0xAA, 0xFE, 0x2B, 0x81, 0x54,
  0x29, 0xFC, 0x56, 0x83, 0xD7, 0x02, 0xA8, 0x7D,
  0x52, 0x87, 0x2D, 0xF8, 0xAC, 0x79, 0xD3, 0x06,
  0x7B, 0xAE, 0x04, 0xD1, 0x85, 0x50, 0xFA, 0x2F,
  0xA4, 0x71, 0xDB, 0x0E, 0x5A, 0x8F, 0x25, 0xF0,
  0x8D, 0x58, 0xF2, 0x27, 0x73, 0xA6, 0x0C, 0xD9,
  0xF6, 0x23, 0x89, 0x5C, 0x08, 0xDD, 0x77, 0xA2,
  0xDF, 0x0A, 0xA0, 0x75, 0x21, 0xF4, 0x5E, 0x8B,
  0x9D, 0x48, 0xE2, 0x37, 0x63, 0xB6, 0x1C, 0xC9,
  0xB4, 0x61, 0xCB, 0x1E, 0x4A, 0x9F, 0x35, 0xE0,
  0xCF, 0x1A, 0xB0, 0x65, 0x31, 0xE4, 0x4E, 0x9B,
  0xE6, 0x33, 0x99, 0x4C, 0x18, 0xCD, 0x67, 0xB2,
  0x39, 0xEC, 0x46, 0x93, 0xC7, 0x12, 0xB8, 0x6D,
  0x10, 0xC5, 0x6F, 0xBA, 0xEE, 0x3B, 0x91, 0x44,
  0x6B, 0xBE, 0x14, 0xC1, 0x95, 0x40, 0xEA, 0x3F,
  0x42, 0x97, 0x3D, 0xE8, 0xBC, 0x69, 0xC3, 0x16,
  0xEF, 0x3A, 0x90, 0x45, 0x11, 0xC4, 0x6E, 0xBB,
  0xC6, 0x13, 0xB9, 0x6C, 0x38, 0xED, 0x47, 0x92,
  0xBD, 0x68, 0xC2, 0x17, 0x43, 0x96, 0x3C, 0xE9,
  0x94, 0x41, 0xEB, 0x3E, 0x6A, 0xBF, 0x15, 0xC0,
  0x4B, 0x9E, 0x34, 0xE1, 0xB5, 0x60, 0xCA, 0x1F,
  0x62, 0xB7, 0x1D, 0xC8, 0x9C, 0x49, 0xE3, 0x36,
  0x19, 0xCC, 0x66, 0xB3, 0xE7, 0x32, 0x98, 0x4D,
  0x30, 0xE5, 0x4F, 0x9A, 0xCE, 0x1B, 0xB1, 0x64,
  0x72, 0xA7, 0x0D, 0xD8, 0x8C, 0x59, 0xF3, 0x26,
  0x5B, 0x8E, 0x24, 0xF1, 0xA5, 0x70, 0xDA, 0x0F,
  0x20, 0xF5, 0x5F, 0x8A, 0xDE, 0x0B, 0xA1, 0x74,
  0x09, 0xDC, 0x76, 0xA3, 0xF7, 0x22, 0x88, 0x5D,
  0xD6, 0x03, 0xA9, 0x7C, 0x28, 0xFD, 0x57, 0x82,
  0xFF, 0x2A, 0x80, 0x55, 0x01, 0xD4, 0x7E, 0xAB,
  0x84, 0x51, 0xFB, 0x2E, 0x7A, 0xAF, 0x05, 0xD0,
  0xAD, 0x78, 0xD2, 0x07, 0x53, 0x86, 0x2C, 0xF9
};

static Mutex crsf_mutex;
static int16_t crsf_channels[CRSF_NUM_CHANNELS];
static uint32_t crsf_last_update_ticks;

static uint8_t crsf_crc8(const uint8_t *data, size_t length) {
    uint8_t crc = 0x00;

    for (size_t i = 0; i < length; i++) {
        crc = crsf_crc8_table[crc ^ data[i]];
    }

    return crc;
}

static void crsf_unpack_channels(const uint8_t *payload, int16_t *channels) {
    int bit_pos = 0;

    for (int channel = 0; channel < CRSF_NUM_CHANNELS; channel++) {
        uint16_t value = 0;

        for (uint32_t b = 0; b < CRSF_BITS_PER_CHANNEL; b++) {
            int byte_index = bit_pos / 8;
            int bit_index = bit_pos % 8;

            if (payload[byte_index] & (1 << bit_index)) {
                value |= (uint16_t) (1U << b);
            }

            bit_pos++;
        }

        channels[channel] = (int16_t) value;
    }
}

void crsf_init(void) {
    mutex_init(&crsf_mutex);
    crsf_last_update_ticks = 0;

    uart_init(CRSF_UART_ID, CRSF_BAUD);
}

void crsf_task(void) {
    uint8_t buffer[CRSF_MAX_FRAME_SIZE];

    for (;;) {
        uint8_t sync_byte = uart_receive_byte(CRSF_UART_ID);

        if (sync_byte != CRSF_SYNC_BYTE) {
            continue;
        }

        uint8_t frame_len;
        if (!uart_receive_byte_timeout(CRSF_UART_ID, &frame_len, CRSF_FRAME_TIMEOUT_MS)) {
            continue;
        }

        if (frame_len < 2 || frame_len > CRSF_MAX_FRAME_SIZE - 2) {
            continue;
        }

        if (!uart_receive_bytes_timeout(CRSF_UART_ID, buffer, frame_len, CRSF_FRAME_TIMEOUT_MS)) {
            continue;
        }

        uint8_t type = buffer[0];
        uint8_t received_crc = buffer[frame_len - 1];
        uint8_t calc_crc = crsf_crc8(buffer, (size_t) frame_len - 1);

        if (received_crc != calc_crc) {
            continue;
        }

        if (type != CRSF_FRAMETYPE_RC_CHANNELS_PACKED) {
            continue;
        }

        if (frame_len != 1 + CRSF_RC_CHANNELS_PAYLOAD_SIZE + 1) {
            continue;
        }

        int16_t channels[CRSF_NUM_CHANNELS];
        crsf_unpack_channels(&buffer[1], channels);

        mutex_lock(&crsf_mutex);
        memcpy(crsf_channels, channels, sizeof(crsf_channels));
        crsf_last_update_ticks = scheduler_get_tick_count();
        mutex_unlock(&crsf_mutex);
    }
}

void crsf_get_channels(int16_t *channels_out) {
    mutex_lock(&crsf_mutex);
    memcpy(channels_out, crsf_channels, sizeof(crsf_channels));
    mutex_unlock(&crsf_mutex);
}

bool crsf_is_stale(uint32_t timeout_ms) {
    mutex_lock(&crsf_mutex);
    uint32_t last_update_ticks = crsf_last_update_ticks;
    mutex_unlock(&crsf_mutex);

    return (scheduler_get_tick_count() - last_update_ticks) > timeout_ms;
}
